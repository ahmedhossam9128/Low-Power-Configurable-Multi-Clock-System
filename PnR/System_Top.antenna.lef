

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO System_Top 
  PIN SI[3] 
    ANTENNAPARTIALMETALAREA 1.402 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 6.74362 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 28.924 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 138.473 LAYER METAL2 ;
    ANTENNAMAXCUTCAR 0.677298 LAYER VIA23 ;
  END SI[3]
  PIN SI[2] 
    ANTENNAPARTIALMETALAREA 2.336 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 11.2362 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 46.4475 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 222.761 LAYER METAL2 ;
    ANTENNAMAXCUTCAR 0.677298 LAYER VIA23 ;
  END SI[2]
  PIN SI[1] 
    ANTENNAPARTIALMETALAREA 1.589 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.64309 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 38.7364 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 189.28 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 2.03189 LAYER VIA34 ;
  END SI[1]
  PIN SI[0] 
    ANTENNAPARTIALMETALAREA 1.976 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.50456 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 39.6932 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 190.273 LAYER METAL2 ;
    ANTENNAMAXCUTCAR 0.677298 LAYER VIA23 ;
  END SI[0]
  PIN SO[3] 
    ANTENNADIFFAREA 0.401 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 3.353 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 16.1279 LAYER METAL3 ;
  END SO[3]
  PIN SO[2] 
    ANTENNADIFFAREA 0.401 LAYER METAL2 ; 
    ANTENNAPARTIALMETALAREA 1.238 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.95478 LAYER METAL2 ;
  END SO[2]
  PIN SO[1] 
    ANTENNADIFFAREA 0.401 LAYER METAL2 ; 
    ANTENNAPARTIALMETALAREA 2.268 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 10.9091 LAYER METAL2 ;
  END SO[1]
  PIN SO[0] 
    ANTENNADIFFAREA 0.401 LAYER METAL2 ; 
    ANTENNAPARTIALMETALAREA 1.334 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 6.41654 LAYER METAL2 ;
  END SO[0]
  PIN REF_CLK 
    ANTENNAPARTIALMETALAREA 0.008 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.03848 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.222 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.26022 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 2.518 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.304 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 1.00451 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 4.97742 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 0.0353598 LAYER VIA45 ;
  END REF_CLK
  PIN UART_CLK 
    ANTENNAPARTIALMETALAREA 0.172 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.82732 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 3.174 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.4593 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 3.42 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.6426 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 2.09893 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 10.2416 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 0.0353598 LAYER VIA45 ;
  END UART_CLK
  PIN RST_N 
    ANTENNAPARTIALMETALAREA 1.917 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.22077 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.25 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3949 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 4.122 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 20.0192 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 90.4878 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 442.61 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 2.70919 LAYER VIA45 ;
  END RST_N
  PIN UART_RX_IN 
    ANTENNAPARTIALMETALAREA 1.549 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.45069 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1404 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 28.9658 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 141.234 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.02849 LAYER VIA34 ;
  END UART_RX_IN
  PIN SE 
    ANTENNAPARTIALMETALAREA 3.699 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 17.7922 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3289 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 12.2128 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 57.7503 LAYER METAL2 ;
    ANTENNAMAXCUTCAR 0.235332 LAYER VIA23 ;
  END SE
  PIN test_mode 
    ANTENNAPARTIALMETALAREA 1.179 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.67099 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.625 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 18.9228 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 90.6315 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 1.50597 LAYER VIA45 ;
  END test_mode
  PIN scan_clk 
    ANTENNAPARTIALMETALAREA 0.008 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.03848 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 3.748 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.2203 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 3.748 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 18.2203 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 1.51156 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 7.41634 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 0.0353598 LAYER VIA45 ;
  END scan_clk
  PIN scan_rst 
    ANTENNAPARTIALMETALAREA 6.158 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 29.8124 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4602 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 34.7315 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 172.681 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 3.01839 LAYER VIA45 ;
  END scan_rst
  PIN UART_TX_O 
    ANTENNADIFFAREA 1.431 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 0.114 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.54834 LAYER METAL3 ;
  END UART_TX_O
  PIN framing_error 
    ANTENNAPARTIALMETALAREA 2.236 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 10.7552 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNADIFFAREA 1.431 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 4.108 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 19.9519 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1547 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 48.0076 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 230.821 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.54274 LAYER VIA34 ;
  END framing_error
  PIN parity_error 
    ANTENNADIFFAREA 1.431 LAYER METAL2 ; 
    ANTENNAPARTIALMETALAREA 1.485 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 7.14285 LAYER METAL2 ;
  END parity_error
END System_Top

END LIBRARY
